# Keil uVision project mountControl.uvprojx, settings and files
target mountControl (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mountControl +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=16000000
  c include: .\;.\cmsis;.\unilib;.\unilib\crc;.\unilib\external_devices;.\unilib\math;.\unilib\mcs;.\unilib\mcs\arm_cm3;.\unilib\mcs\stm32;.\unilib\proto;.\StdPeriph\inc;.\hdr
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./cmsis/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group StdLib
    ./StdPeriph/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c
  group unilib
    ./unilib/: fifo.c
    ./unilib/mcs/stm32/: uart.c systick_timer.c rcc.c
  group userSrc
    ./Src/: main.c
