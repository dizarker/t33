# Keil uVision project RFControl.uvprojx, settings and files
target RFControl (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RFControl
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F411xE, USE_STDPERIPH_DRIVER
  c include: .\STDDriver\inc;.\CMSIS;..\RFControl;.\TFTLCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c startup_stm32f401xx.s
  group STDDriver
    ./STDDriver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_gpio.c
  group Source
    ./: main.c nrfRadio.c
